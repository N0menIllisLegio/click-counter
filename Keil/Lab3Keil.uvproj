# Keil uVision project Lab3Keil.uvproj, settings and files
target STM32_Lab3 (ARM-ADS)
  device: STM32F103T6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab3Keil +hex
  c flags: Optim=1 uC99=1
  c include: .\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Keil;.\Src;.\Drivers\STM32F1xx_HAL_Driver\Src;.\Drivers\CMSIS\Device\ST\STM32F1xx\Source
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group StartUp
    ./: startup_stm32f10x_ld.s
  group CMSIS
    ./Src/: system_stm32f1xx.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Source Files
    ./Src/: main.c
  group HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_exti.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c
